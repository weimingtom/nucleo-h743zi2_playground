# Keil uVision project h743_inmp441.uvprojx, settings and files
target h743_inmp441 (6100001::V6.10.1::.\ARMCLANG)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: h743_inmp441 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32H743xx,TF_LITE_STATIC_MEMORY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../packs/flatbuffers/1.12.0/src/include;../packs/gemmlowp/1.0.0/src;../packs/kissfft/1.3.1/src;../packs/ruy/1.0.0/src;../packs/tensorflow-lite/2.4.0;../packs/tensorflow-lite/2.4.0/tensorflow/lite/;../packs/tensorflow-lite/2.4.0/tensorflow/lite/c;../packs/tensorflow-lite/2.4.0/tensorflow/lite/core/api;../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels;../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal;../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/optimized;../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference;../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/integer_ops;../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro;../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/benchmarks;../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels;../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/memory_planner;../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/testing;../packs/tensorflow-lite/2.4.0/tensorflow/lite/schema;../src;../src/i.MXRT
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
    ../Core/Inc/: fsl_debug_console.h
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group machine_learning
    ../packs/tensorflow-lite/2.4.0/tensorflow/core/public/: version.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/: portable_type_to_tflitetype.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/c/: builtin_op_data.h common.c common.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/core/api/: error_reporter.cc error_reporter.h flatbuffer_conversions.cc flatbuffer_conversions.h op_resolver.cc op_resolver.h profiler.h tensor_utils.cc tensor_utils.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/: kernel_util.h kernel_util_.cc op_macros.h padding.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/: compatibility.h cppmath.h max.h min.h portable_tensor.h quantization_util.cc quantization_util.h strided_slice_logic.h tensor_ctypes.h types.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/optimized/: neon_check.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/: add.h arg_min_max.h binary_function.h ceil.h comparisons.h concatenation.h conv.h depthwiseconv_float.h depthwiseconv_uint8.h dequantize.h floor.h fully_connected.h hard_swish.h l2normalization.h logistic.h maximum_minimum.h mul.h neg.h pad.h pooling.h prelu.h process_broadcast_shapes.h quantize.h reduce.h requantize.h resize_nearest_neighbor.h round.h softmax.h strided_slice.h sub.h tanh.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/kernels/internal/reference/integer_ops/: depthwise_conv.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/: all_ops_resolver.cc all_ops_resolver.h debug_log.cc debug_log.h memory_helpers.cc memory_helpers.h micro_allocator.cc micro_allocator.h micro_error_reporter.cc micro_error_reporter.h micro_interpreter.cc micro_interpreter.h micro_mutable_op_resolver.h micro_op_resolver.h micro_optional_debug_tools.cc micro_optional_debug_tools.h micro_profiler.cc micro_profiler.h micro_string.cc micro_string.h micro_time.cc micro_time.h micro_utils.cc micro_utils.h recording_micro_allocator.cc recording_micro_allocator.h recording_micro_interpreter.h recording_simple_memory_allocator.cc recording_simple_memory_allocator.h simple_memory_allocator.cc simple_memory_allocator.h test_helpers.cc test_helpers.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/benchmarks/: keyword_scrambled_model_data.cc keyword_scrambled_model_data.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/kernels/: activation_utils.h activations.cc add.cc arg_min_max.cc ceil.cc circular_buffer.cc comparisons.cc concatenation.cc conv.cc depthwise_conv.cc dequantize.cc elementwise.cc ethosu.cc floor.cc fully_connected.cc hard_swish.cc kernel_runner.cc kernel_runner.h kernel_util.cc l2norm.cc logical.cc logistic.cc maximum_minimum.cc micro_ops.h mul.cc neg.cc pack.cc pad.cc pooling.cc prelu.cc quantize.cc reduce.cc reshape.cc resize_nearest_neighbor.cc round.cc softmax.cc split.cc strided_slice.cc sub.cc svdf.cc tanh.cc unpack.cc
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc greedy_memory_planner.h linear_memory_planner.cc linear_memory_planner.h memory_planner.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/micro/testing/: micro_test.h test_conv_model.cc test_conv_model.h test_utils.cc test_utils.h
    ../packs/tensorflow-lite/2.4.0/tensorflow/lite/schema/: schema_generated.h
  group src
    ../src/: audio_provider.cc audio_provider.h audio_provider_default.cc audio_provider_test.cc command_responder.cc command_responder.h feature_provider.cc feature_provider.h feature_provider_test.cc main.cc main_functions.cc main_functions.cc.bak main_functions.h main_functions_test.cc output_handler.cc output_handler.h Platform.c recognize_commands.cc recognize_commands.h todo.txt
    ../src/i.MXRT/: main.c main.h retarget_stdio.c
    ../src/micro_features/: micro_features_generator.cc micro_features_generator.h micro_model_settings.cc micro_model_settings.h model.cc model.cc.bak model.h no_micro_features_data.cc no_micro_features_data.h yes_micro_features_data.cc yes_micro_features_data.h
    ../src/micro_frontend/lib/: bits.h BUILD fft.cc fft.h fft_io.c fft_io.h fft_test.cc fft_util.cc fft_util.h filterbank.c filterbank.h filterbank_io.c filterbank_io.h filterbank_test.cc filterbank_util.c filterbank_util.h frontend.c frontend.h frontend_io.c frontend_io.h frontend_main.c frontend_memmap_generator.c frontend_memmap_main.c frontend_test.cc frontend_util.c frontend_util.h log_lut.c log_lut.h log_scale.c log_scale.h log_scale_io.c log_scale_io.h log_scale_test.cc log_scale_util.c log_scale_util.h malloc.c malloc.h noise_reduction.c noise_reduction.h noise_reduction_io.c noise_reduction_io.h noise_reduction_test.cc noise_reduction_util.c noise_reduction_util.h pcan_gain_control.c pcan_gain_control.h pcan_gain_control_test.cc pcan_gain_control_util.c pcan_gain_control_util.h README.md window.c window.h window_io.c window_io.h window_test.cc window_util.c window_util.h
    ../src/test/: no_30ms_sample_data.cc no_30ms_sample_data.h no_1000ms_sample_data.cc no_1000ms_sample_data.h yes_30ms_sample_data.cc yes_30ms_sample_data.h yes_1000ms_sample_data.cc yes_1000ms_sample_data.h
  group kissfft
    ../packs/kissfft/1.3.1/src/: .gitignore .travis.yml _kiss_fft_guts.h CHANGELOG CMakeLists.txt COPYING kiss_fft.c kiss_fft.h kiss_fft_log.h kissfft.hh kissfft_i32.hh Makefile README README.md README.simd TIPS
    ../packs/kissfft/1.3.1/src/tools/: fftutil.c kfc.c kfc.h kiss_fastfir.c kiss_fftnd.c kiss_fftnd.h kiss_fftndr.c kiss_fftndr.h kiss_fftr.c kiss_fftr.h psdpng.c
software components: CMSIS:CORE 5.5.0
